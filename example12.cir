R1 1 2 100
R2 1 3 82
L1 1 4 68e-3
L2 1 3 68e-3
C1 1 4 47e-6
C2 2 5 300e-6
C3 6 3 300e-6
R3 4 6 47
L3 5 4 22e-3
L4 0 6 68e-3
L5 7 3 33e-3
R4 6 8 51
C4 8 7 300e-6
C5 1 8 47e-6
V1 1 0 30
