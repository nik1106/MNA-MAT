R1 1 2 5
R2 1 3 10
R3 2 0 15
R4 3 0 20
C1 2 3 47E-06
V1 1 0 5
