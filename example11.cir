V1 1 0 10
R1 2 1 4
R2 3 4 6
R3 2 3 5
R4 1 4 3
V2 3 5 3
R5 4 6 2
R6 2 7 7
R7 0 6 1
L1 5 6 30e-3
C1 4 0 10e-6
C2 8 5 2e-6
L2 7 8 50e-3
