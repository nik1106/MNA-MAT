V1 1 0 10
C1 1 2 47E-06
C2 1 2 22E-06
R1 2 0 3300
G1 1 0 1 2 4E-2
