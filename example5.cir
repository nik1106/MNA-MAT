V1 1 2 32
R1 1 0 2
R2 2 3 4
R3 2 0 8
V2 3 0 20
E1 1 0 2 3 5
